# Keil uVision project printer.uvproj, settings and files
target Printer (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: printer +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,STATIC=static
  c include: ..\src;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\src\misc;..\src\usart;..\src\com;..\src\storage;..\src\printer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../src/: main.c stm32f10x_it.c
    ../src/misc/: utils.c buzzer.c led.c watchdog.c timer_list.c debug.c button.c
    ../src/usart/: ringbuf.c usart_io.c
    ../src/printer/: printer.c
    ../src/com/: com_utils.c com_gsm.c com_msghandler.c
    ../src/storage/: config.c ff.c mmc_stm32f1.c onchip_flash.c conf_parser.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c
  group LIB
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_iwdg.c stm32f10x_flash.c
    ../src/: startup_stm32f10x_md.s
